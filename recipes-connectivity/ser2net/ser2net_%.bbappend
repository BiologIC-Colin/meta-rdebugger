# rdebugger: run ser2net unprivileged with the configuration generated by
# rdebugger-setup (/run/rdebugger/ser2net.yaml), restarting on failure.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://ser2net-rdebugger.conf"

do_install:append() {
    install -d ${D}${systemd_system_unitdir}/ser2net.service.d
    install -m 0644 ${UNPACKDIR}/ser2net-rdebugger.conf \
        ${D}${systemd_system_unitdir}/ser2net.service.d/50-rdebugger.conf
}

FILES:${PN} += "${systemd_system_unitdir}/ser2net.service.d"
